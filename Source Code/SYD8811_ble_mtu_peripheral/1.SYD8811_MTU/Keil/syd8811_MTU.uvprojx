# Keil uVision project syd8811_MTU.uvprojx, settings and files
target syd8811_mtu (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: syd8811_mtu +hex
  AfterMake: "Output\HEX2BIN.EXE" "Output\syd8811_mtu.hex"
  AfterMake: fromelf -c  .\output\syd8811_mtu.axf  -o  .\output\syd8811_mtu.txt
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Include;..\..\..\BLE;..\..\Lib;..\..\..\RTT;..\profile;..\
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x3f000
  memory RVCT9: RAM 0x20003000 size 0x5000
  group Main
    ../: main.c
  group Driver
    ../../../Driver/: gpio.c delay.c
    ../../../BLE/: ota.c
    ../: timer_handler.c rtc_handler.c
  group BLE
    ../../../Lib/: Syd8811_softtimer_lib.lib
    ../../Lib/: syd8811_ble_mtu_lib.lib
  group Rtt
    ../../../Rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.1
