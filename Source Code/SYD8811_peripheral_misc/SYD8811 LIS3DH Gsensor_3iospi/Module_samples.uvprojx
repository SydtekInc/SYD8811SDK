# Keil uVision project Module_samples.uvprojx, settings and files
target Module_samples (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Module_samples +hex
  c flags: OneElfS=1 wLevel=2
  c include: .\Include;.\Main
  library: MicroLIB
  memory RVCT4: ROM 0x6000 size 0x8000
  memory RVCT9: RAM 0x20001000 size 0x2000
  group Main
    ./Main/: main.c led.c key.c oled.c lis3dh.c
  group Driver
    ./Driver/: syd8801_gpio.c syd8801_delay.c syd8801_timer.c syd8801_uart.c syd8801_wdt.c syd8801_pwm.c syd8801_debug.c syd8801_adc.c syd8801_ioi2c.c syd8801_iospi.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
