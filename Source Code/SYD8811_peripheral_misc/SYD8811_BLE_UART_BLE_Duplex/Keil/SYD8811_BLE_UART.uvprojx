# Keil uVision project SYD8811_BLE_UART.uvprojx, settings and files
target SYD8811 (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: Ble_Vendor_Service +hex
  AfterMake: "Output\HEX2BIN.EXE" "Output\Ble_Vendor_Service.hex"
  AfterMake: fromelf -c  .\output\Ble_Vendor_Service.axf  -o  .\output\Ble_Vendor_Service_assembly.txt
  c define: _DEFIND_SYD8811_
  c include: ..\..\..\Include;..\..\..\BLE;..\..\..\Lib;..\profile;..\;..\..\..\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x3f000
  memory RVCT9: RAM 0x20003000 size 0x5000
  group Main
    ../: main.c uart_protocol.c
    ../../../Driver/: delay.c
  group Driver
    ../../../ble/: ota.c
    ../../../Driver/: gpio.c
    ../: uart.c timer_handler.c rtc_handler.c
  group BLE
    ../../../Lib/: syd8811_ble_lib.lib Syd8811_softtimer_lib.lib
  group RTT
    ../../../Rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
target SYD8810 (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: Ble_Vendor_Service +hex
  AfterMake: "Output\HEX2BIN.EXE" "Output\Ble_Vendor_Service.hex"
  AfterMake: as above
  c define: _DEFIND_SYD8810_
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x3f000
  memory RVCT9: RAM 0x20003000 size 0x5000
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.1
