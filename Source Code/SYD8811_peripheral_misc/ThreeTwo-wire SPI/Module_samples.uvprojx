# Keil uVision project Module_samples.uvprojx, settings and files
target Module_samples (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Vendor_Services +hex
  AfterMake: "Output\HEX2BIN.EXE" "Output\Vendor_Services.hex"
  AfterMake: "Output\BIN2MIF.exe" "0" "Output\Vendor_Services.hex"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Main
    ./Main/: main.c lis3dh.c
  group Driver
    ./Driver/: debug.c uart.c gpio.c delay.c wdt.c spi.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
