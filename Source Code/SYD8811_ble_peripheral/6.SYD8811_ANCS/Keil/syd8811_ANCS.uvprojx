# Keil uVision project syd8811_ANCS.uvprojx, settings and files
target syd8811_hid (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: syd8811_hid +hex
  AfterMake: "Output\HEX2BIN.EXE" "Output\syd8811_hid.hex"
  AfterMake: fromelf -c  .\output\syd8811_hid.axf  -o  .\output\syd8811_hid.txt
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Include;..\..\..\BLE;..\..\..\Lib;..\..\..\RTT;..\profile;..\
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x3f000
  memory RVCT9: RAM 0x20003000 size 0x5000
  group Main
    ../: main.c
  group Driver
    ../../../Driver/: debug.c gpio.c uart.c delay.c
    ../../../BLE/: ota.c
    ../: timer_handler.c rtc_handler.c
  group BLE
    ../../../Lib/: Syd8811_softtimer_lib.lib syd8811_ble_lib.lib Syd8811_ancs_lib.lib
  group Rtt
    ../../../Rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.1
