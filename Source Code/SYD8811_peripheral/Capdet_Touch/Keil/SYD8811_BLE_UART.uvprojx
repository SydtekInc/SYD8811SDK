# Keil uVision project SYD8811_BLE_UART.uvprojx, settings and files
target SYD8811 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: Ble_Vendor_Service +hex
  AfterMake: "Output\HEX2BIN.EXE" "Output\Ble_Vendor_Service.hex"
  AfterMake: fromelf -c  .\output\Ble_Vendor_Service.axf  -o  .\output\Ble_Vendor_Service_assembly.txt
  c include: ..\..\..\Include;..\..\..\BLE;..\..\..\Lib;..\profile;..\;..\..\..\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x3f000
  memory RVCT9: RAM 0x20003000 size 0x5000
  group Main
    ../: main.c
    ../../../Driver/: delay.c
  group Capdet
    ../: capdet_touch.h capdet_touch.c capdet_alg_lib.h capdet_alg_lib.lib
  group Driver
    ../../../ble/: ota.c
    ../../../Driver/: gpio.c
    ../: timer_handler.c rtc_handler.c
  group BLE
    ../../../Lib/: syd8811_ble_lib.lib Syd8811_softtimer_lib.lib
  group RTT
    ../../../Rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.1
