# Keil uVision project BLE_RTOS.uvprojx, settings and files
target SYD8811_FreeRTOS_Cache (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: SYD8811_FreeRTOS +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c include: ..\..\..\Lib;..\..\..\BLE;..\..\..\FreeRTOS\source\include;..\..\..\FreeRTOS\config;..\..\..\FreeRTOS\portable\ARM\SYD8811;..\..\..\FreeRTOS\portable\CMSIS\SYD8811;..\..\..\Include;..\application;..\profile;..\
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x3f000
  memory RVCT9: RAM 0x20003000 size 0x5000
  group Application
    ../: main.c
  group BLE
    ../application/: ble.c
  group Driver
    ../../../Driver/: debug.c gpio.c uart.c
  group FreeRTOS
    ../../../FreeRTOS/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../FreeRTOS/source/portable/MemMang/: heap_4.c
    ../../../FreeRTOS/portable/ARM/SYD8811/: port.c
  group Libraries
    ../../../Lib/: syd8811_ble_lib.lib
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.1
