# Keil uVision project Syd8811_Peripheral.uvprojx, settings and files
target Syd8811_Peripheral (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: Syd8811_Peripheral +hex
  AfterMake: "Output\HEX2BIN.EXE" "Output\Syd8811_Peripheral.hex"
  AfterMake: fromelf -c  .\output\Syd8811_Peripheral.axf  -o  .\output\Syd8811_Peripheral.txt
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Include;..\..\..\ble;..\..\..\Lib;..\
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x3f000
  memory RVCT9: RAM 0x20003000 size 0x5000
  group Main
    ../: main.c
  group Driver
    ../../../Driver/: debug.c uart.c gpio.c delay.c atr_decoder.c sc_reader.c tpdu.c queue.c
  group BLE
    ../../../Lib/: syd8811_ble_lib.lib
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.1
