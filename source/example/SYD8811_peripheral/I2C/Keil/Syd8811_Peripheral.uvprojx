# Keil uVision project Syd8811_Peripheral.uvprojx, settings and files
target Syd8811_Peripheral (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: Syd8811_Peripheral +hex
  AfterMake: "Output\HEX2BIN.EXE" "Output\Syd8811_Peripheral.hex"
  AfterMake: fromelf -c  .\output\Syd8811_Peripheral.axf  -o  .\output\Syd52832_Peripheral.txt
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\BLE;..\..\..\Include;..\..\..\Lib;..\
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x3f000
  memory RVCT9: RAM 0x20003000 size 0x5000
  group Main
    ../: main.c
  group Driver
    ../../../Driver/: delay.c gpio.c timer.c debug.c uart.c gpadc.c wdt.c i2c.c
    ../: gsensor.c
  group BLE
    ../../../Lib/: syd8811_ble_lib.lib
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.1
